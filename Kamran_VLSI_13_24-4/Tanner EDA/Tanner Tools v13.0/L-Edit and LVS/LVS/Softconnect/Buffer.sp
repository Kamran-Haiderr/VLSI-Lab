* SPICE netlist written by S-Edit

* Main circuit: Buffer
MN1 N1 In Gnd Gnd NMOS L=0.7u W=9.8u
MP1 N1 In Vdd Vdd PMOS L=0.7u W=9.8u
MN2 Out N1 Gnd Gnd NMOS L=0.7u W=9.8u
MP2 Out N1 Vdd Vdd PMOS L=0.7u W=9.8u

* End of main circuit: Buffer
